# Repository MacgyverLin/VGMPlayer

## KiCad design Hardware/VGMPlayer/VGMPlayer.kicad_pcb

Parts:
C1, C2, C14, C15, C17, C18: 100uF; CP_Radial_D8.0mm_P3.50mm
C3, C10, C21, C22, C23, C24: 1000uF; CP_Radial_D8.0mm_P3.50mm
C4: 220pF; C_0805_2012Metric
C5, C6: 10uF; CP_Radial_D4.0mm_P1.50mm
C7, C27, C28: 1uF; CP_Radial_D4.0mm_P1.50mm
C8, C9: 4.7nF; C_0805_2012Metric
C11, C12: 16uF; CP_Radial_D4.0mm_P1.50mm
C19, C20: 47nF; C_0805_2012Metric
C25, C26: 10nF; C_0805_2012Metric
C29: 10uF; CP_Radial_D8.0mm_P3.50mm
C30, C31: 1.5nF; C_0805_2012Metric
C100, C101: TBD; C_0805_2012Metric
D0, D1, D2, D3, D4, D5, D6, D7: LED; LED_0805_2012Metric
J1: USB_B_Mini; USB_Micro-B_Wuerth_629105150521_CircularHoles
J2: SD_Card; SD_TE_2041021
J3: LCD_PORT; PinSocket_2x15_P2.54mm_Vertical
L1, L2: 30uH; L_0805_2012Metric
Q1: 9013; TO-92
Q2: S8550; TO-92
R1, R16, R17: 0; R_0805_2012Metric
R2, R3, R4, R5, R6: 2.2k; R_0805_2012Metric
R7, R8: 51k; R_0805_2012Metric
R9, R10: 10k; R_0805_2012Metric
R11, R12: 11k; R_0805_2012Metric
R13, R14: 10; R_0805_2012Metric
R15: 270; R_0805_2012Metric
R18, R19, R20, R21, R22, R23, R24, R25: 330; R_0805_2012Metric
R26: 47k; R_0805_2012Metric
R27: 1k; R_0805_2012Metric
R28: 4.7k; R_0805_2012Metric
R29, R30, R100, R101, R102, R103: TBD; R_0805_2012Metric
SW1: Mode; VGM_Button
SW2: NEXT; VGM_Button
SW3: PREV; VGM_Button
SW4: SELECT; VGM_Button
SW5: PWR; VGM_Button
U1: STM32F103XX; DIP-40_W15.24mm_Socket
U2: SDCardModule; PinHeader_1x08_P2.54mm_Vertical
U3, U4: LM386; DIP-8_W7.62mm_Socket
U5: YM2151; DIP-24_W15.24mm_Socket
U6: AUDIOJACK-VGM; VGMAudio_Jack
U7: YM2612; DIP-24_W15.24mm_Socket
U8: SN76489; DIP-16_W7.62mm_Socket
U9, U10: LTC6903; MSOP-8_3x3mm_P0.65mm
U11: HC-06; PinSocket_1x06_P2.54mm_Vertical
U12: R_POT_SW; VGM_VR_SW
U13: YM3012; DIP-16_W7.62mm_Socket
U14: LM324; DIP-14_W7.62mm
U19: ESP8266Module; PinSocket_1x06_P2.54mm_Vertical

Connections:
+3V3: J2.6 (VSS), R30.1, U1.40 (3.3V), U2.7 (3v3), U11.2 (VCC), U19.2 (VCC)
+5V: C2.1, C3.1, C14.1, C15.1, C24.1, L2.2, Q2.3 (C), R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R29.1, U3.6 (V+), U4.6 (V+), U7.22 (AVCC), U8.16 (VCC), U13.1 (VDD), U14.4 (V+)
A0: J3.30, U1.15 (B10), U5.4 (A0), U7.17 (A0)
A1: U1.16 (B11), U7.18 (A1)
BUTTON_MODE: SW1.1, U1.30 (A15)
BUTTON_NEXT: SW2.1, U1.29 (A12)
BUTTON_PREV: SW3.1, U1.28 (A11)
BUTTON_SELECT: SW4.1, U1.25 (A8)
D0: D0.1 (K), J3.26, U1.5 (A0), U5.10 (D0), U7.2 (D0), U8.10 (D0)
D1: D1.1 (K), J3.23, U1.6 (A1), U5.12 (D1), U7.3 (D1), U8.11 (D1)
D2: D2.1 (K), J3.24, U1.7 (A2), U5.13 (D2), U7.4 (D2), U8.12 (D3)
D3: D3.1 (K), J3.21, U1.8 (A3), U5.14 (D3), U7.5 (D3), U8.13 (D4)
D4: D4.1 (K), J3.22, U1.9 (A4), U5.15 (D4), U7.6 (D4), U8.15 (D5)
D5: D5.1 (K), J3.19, U1.10 (A5), U5.16 (D5), U7.7 (D5), U8.1 (D5)
D6: D6.1 (K), J3.20, U1.11 (A6), U5.17 (D6), U7.8 (D6), U8.2 (D6)
D7: D7.1 (K), J3.17, U1.12 (A7), U5.18 (D7), U7.9 (D7), U8.3 (D7)
GND: C1.2, C10.2, C23.2, J2.4 (VDD), J2.8 (DAT1), J2.11 (SHELL1), J3.1, L1.1, SW1.2, SW2.2, SW3.2, SW4.2, U1.19 (GND), U1.20 (GND), U1.39 (GND), U2.1 (GND), U2.8 (GND), U5.1 (GND), U5.11 (GND), U7.1 (GND), U7.12 (GND), U11.3 (GND), U13.3 (DGND), U19.3 (GND)
GNDA: C2.2, C3.2, C4.2, C14.2, C15.2, C17.2, C18.2, C24.2, C25.1, C26.1, C27.2, C28.2, C29.2, C30.1, C31.1, C100.2, C101.2, J1.5 (GND), J1.6 (Shield), L1.2, Q1.2 (E), R2.1, R3.1, R4.1, R13.2, R14.2, R100.1, R101.1, SW5.1, U3.2 (-), U3.4 (GND), U4.2 (-), U4.4 (GND), U6.3 (S), U7.19 (AGND), U8.6 (/OE), U8.8 (GND), U9.1 (GND), U10.1 (GND), U12.3, U12.6, U13.8 (AGND), U13.16 (AGND), U14.11 (V-)
unnamed: C5.2, R5.2, R100.2
unnamed: C6.2, R6.2, R101.2
unnamed: C7.2, R7.2, R8.2
unnamed: C8.1, R9.2, U12.2
unnamed: C8.2, R9.1, R11.2
unnamed: C9.1, R10.2, U12.5
unnamed: C9.2, R10.1, R12.2
unnamed: C10.1, J3.2, J3.4, R29.2, R30.2
unnamed: C11.1, R11.1
unnamed: C11.2, U3.3 (+)
unnamed: C12.1, R12.1
unnamed: C12.2, U4.3 (+)
unnamed: C17.1, U3.7 (BYPASS)
unnamed: C18.1, U4.7 (BYPASS)
unnamed: C19.1, R13.1
unnamed: C19.2, C21.1, U3.5
unnamed: C20.1, R14.1
unnamed: C20.2, C22.1, U4.5
unnamed: C21.2, U6.1 (T)
unnamed: C22.2, U6.2 (R)
unnamed: C29.1, U13.15 (RB), U14.3 (+)
unnamed: C30.2, U13.10 (VOUT2), U14.10 (+)
unnamed: C31.2, U13.9 (VOUT1), U14.12 (+)
unnamed: D0.2 (A), R25.1
unnamed: D1.2 (A), R24.1
unnamed: D2.2 (A), R23.1
unnamed: D3.2 (A), R22.1
unnamed: D4.2 (A), R21.1
unnamed: D5.2 (A), R20.1
unnamed: D6.2 (A), R19.1
unnamed: D7.2 (A), R18.1
unnamed: Q1.1 (B), R28.1
unnamed: Q1.3 (C), R26.1, R27.1, SW5.2
unnamed: Q2.2 (B), R27.2
unnamed: R1.1, U5.2 (/IRQ)
unnamed: R5.1, R8.1, U12.1
unnamed: R6.1, R7.1, U12.4
unnamed: R15.1, U14.6 (-), U14.7
unnamed: R15.2, U13.11 (COM)
unnamed: R16.1, U5.8 (CT1)
unnamed: R17.1, U5.9 (CT2)
unnamed: U5.23 (Phi0), U13.2 (Phi0)
unnamed: U5.21 (SO), U13.4 (SO)
unnamed: U5.20 (SH1), U13.5 (SH1)
unnamed: U5.19 (SH2), U13.6 (SH2)
unnamed: U13.12 (TO_BUFF), U14.5 (+)
unnamed: U13.13 (MP), U14.1
unnamed: U13.14 (BC), U14.2 (-)
PWR_HOLD: R28.2
PWR_USB: J1.1 (VBUS), Q2.1 (E), R26.2
READY: U8.4 (Ready)
RXD: U1.27 (A10), U11.4 (TXD), U19.4 (TXD)
SD_CS: J2.2 (CMD)
SN_CLK: U8.14 (CLK), U10.6 (/CLK)
SN_CLK_CS: R103.2, U1.37 (B9), U10.4 (SEN)
SN_OUT: C4.1, C7.1, R2.2, U8.7 (SN_OUT)
SN_WR: R102.2, U1.36 (B8), U8.5 (/WE)
SPI_CLK: J2.7 (DAT0), U1.22 (B13), U2.3 (SCK), U9.3 (SCK), U10.3 (SCK)
SPI_MISO: J2.9 (DAT2), U1.23 (B14), U2.2 (MISO)
SPI_MOSI: J2.3 (VSS), U1.24 (B15), U2.4 (MOSI), U9.2 (SDI), U10.2 (SDI)
TXD: U1.26 (A9), U11.5 (RXD), U19.5 (RXD)
VDD: C1.1, C23.1, C25.2, C26.2, C27.1, C28.1, L2.1, U1.38 (5V), U5.22 (VDD), U7.23 (VCC), U9.7 (OE), U9.8 (VCC), U10.7 (OE), U10.8 (VCC)
YM_CLK: U5.24 (PhiM), U7.24 (CLK), U9.6 (/CLK)
YM_CLK_CS: U1.32 (B4), U9.4 (SEN)
YM_MOL: C5.1, C100.1, R3.2, R103.1, U7.21 (MOL), U14.8, U14.9 (-)
YM_MOR: C6.1, C101.1, R4.2, R102.1, U7.20 (MOR), U14.13 (-), U14.14
~LCD_CS: J3.29, U1.34 (B6)
~RD: J3.28, U1.35 (B7)
~RESET: J3.25, U1.21 (B12), U5.3 (/IC), U7.11 (IC), U13.7 (/IC)
~SD_CS: U1.33 (B5), U2.5 (CS)
~VGM_CS: U1.31 (B3)
~WR: J3.27, U1.14 (B1), U5.5 (/WR), U7.15 (/WR)
~YM_CS: U1.13 (B0), U5.7 (/CS), U7.14 (/CS)

Board: 2 copper layers, 100.0 x 98.8 mm, 100 parts (0 on the bottom side), 87 nets.
