# Repository MacgyverLin/VGMPlayer (continued)

## KiCad design noCPU/noCPU/noCPU.kicad_pcb

Parts:
C1, C5, C6, C7: 0.1uF; C_0805_2012Metric
C2, C3: 1uF; CP_Radial_D8.0mm_P3.50mm
C4: 0.1uF; CP_Radial_D8.0mm_P3.50mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62: LED; LED_0805_2012Metric
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R13, R14, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R61, R62, R63, R64: 330; R_0805_2012Metric
R12, R15, R59, R60, R65, R66, R67, R68, R69, R70: 1k; R_0805_2012Metric
RV1, RV2: 100k; PinHeader_1x03_P2.54mm_Horizontal
SW1: SW_DIP_x08; DIP-4_W7.62mm
SW2, SW3: SW_SPDT; DIP-4_W7.62mm
SW4: SW_Push; DIP-4_W7.62mm
U1, U2, U3, U5, U25, U26, U27, U29, U30, U31: 74HC173; DIP-16_W7.62mm
U4, U9: 74HC157; DIP-16_W7.62mm
U6, U8, U11, U36: 62256; DIP-28_W15.24mm
U7, U23, U28, U35: 74HC161; DIP-16_W7.62mm
U10: 74LS138; DIP-18_W7.62mm
U12, U14, U15, U16, U17, U18: 74HC245; DIP-20_W7.62mm
U13, U19, U24, U32: MAN71A
U20, U21: 74HC283; DIP-16_W7.62mm
U22, U43, U44, U45: LM555; DIP-8_W7.62mm
U33, U34: 74HC86; DIP-14_W7.62mm
U37, U40, U41: 74AHC1G08; DIP-14_W7.62mm
U38: 74AHC1G32; DIP-14_W7.62mm
U39, U42: 74AHC1G04; DIP-14_W7.62mm

Connections (part):
/SEG0: U13.1 (A), U19.1 (A), U24.1 (A), U32.1 (A), U36.11 (IO0)
/SEG1: U13.13 (B), U19.13 (B), U24.13 (B), U32.13 (B), U36.12 (IO1)
/SEG2: U13.10 (C), U19.10 (C), U24.10 (C), U32.10 (C), U36.13 (IO2)
/SEG3: U13.8 (D), U19.8 (D), U24.8 (D), U32.8 (D), U36.15 (IO3)
/SEG4: U13.7 (E), U19.7 (E), U24.7 (E), U32.7 (E), U36.16 (IO4)
/SEG5: U13.2 (F), U19.2 (F), U24.2 (F), U32.2 (F), U36.17 (IO5)
/SEG6: U13.11 (G), U19.11 (G), U24.11 (G), U32.11 (G), U36.18 (IO6)
/SEG7: U13.9 (D.P.), U19.9 (D.P.), U24.9 (D.P.), U32.9 (D.P.), U36.19 (IO7)
BUS_D0: R27.1, U2.14 (D0), U5.14 (D0), U6.11 (IO0), U12.18 (B0), U14.18 (B0), U15.18 (B0), U16.18 (B0), U17.18 (B0), U18.18 (B0), U25.14 (D0), U26.14 (D0), U27.14 (D0), U28.3 (D0)
BUS_D1: R28.1, U2.13 (D1), U5.13 (D1), U6.12 (IO1), U12.17 (B1), U14.17 (B1), U15.17 (B1), U16.17 (B1), U17.17 (B1), U18.17 (B1), U25.13 (D1), U26.13 (D1), U27.13 (D1), U28.4 (D1)
BUS_D2: R29.1, U2.12 (D2), U5.12 (D2), U6.13 (IO2), U12.16 (B2), U14.16 (B2), U15.16 (B2), U16.16 (B2), U17.16 (B2), U18.16 (B2), U25.12 (D2), U26.12 (D2), U27.12 (D2), U28.5 (D2)
BUS_D3: R30.1, U2.11 (D3), U5.11 (D3), U6.15 (IO3), U12.15 (B3), U14.15 (B3), U15.15 (B3), U16.15 (B3), U17.15 (B3), U18.15 (B3), U25.11 (D3), U26.11 (D3), U27.11 (D3), U28.6 (D3)
BUS_D4: R31.1, U1.14 (D0), U3.14 (D0), U6.16 (IO4), U12.14 (B4), U14.14 (B4), U15.14 (B4), U16.14 (B4), U17.14 (B4), U18.14 (B4), U23.3 (D0), U29.14 (D0), U30.14 (D0), U31.14 (D0)
BUS_D5: R32.1, U1.13 (D1), U3.13 (D1), U6.17 (IO5), U12.13 (B5), U14.13 (B5), U15.13 (B5), U16.13 (B5), U17.13 (B5), U18.13 (B5), U23.4 (D1), U29.13 (D1), U30.13 (D1), U31.13 (D1)
BUS_D6: R33.1, U1.12 (D2), U3.12 (D2), U6.18 (IO6), U12.12 (B6), U14.12 (B6), U15.12 (B6), U16.12 (B6), U17.12 (B6), U18.12 (B6), U23.5 (D2), U29.12 (D2), U30.12 (D2), U31.12 (D2)
BUS_D7: R34.1, U1.11 (D3), U3.11 (D3), U6.19 (IO7), U12.11 (B7), U14.11 (B7), U15.11 (B7), U16.11 (B7), U17.11 (B7), U18.11 (B7), U23.6 (D3), U29.11 (D3), U30.11 (D3), U31.11 (D3)
CE: U28.7 (CEP), U28.10 (CET)
CLK_MANUAL: R63.1, U41.2, U44.3 (Q)
CLK_SELECT: R64.1, U40.2, U42.2, U45.3 (Q)
CLK_SOURCE: R62.1, U40.1, U43.3 (Q)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), D61.1 (K), D62.1 (K), SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW1.6, SW1.7, SW1.8, SW2.2 (B), SW4.1, U1.1 (~OE1), U1.2 (~OE2), U1.8 (GND), U1.15 (R), U2.1 (~OE1), U2.2 (~OE2), U2.8 (GND), U2.15 (R), U3.1 (~OE1), U3.2 (~OE2), U3.8 (GND)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
HLT: U8.19 (IO7), U39.2
J: U11.12 (IO1), U23.9 (~PE), U28.9 (~PE)
MAR0: R8.1, U6.21 (A0), U9.4 (Za)
MAR1: R7.1, U6.23 (A1), U9.7 (Zb)
MAR2: R6.1, U6.24 (A2), U9.12 (Zc)
MAR3: R5.1, U6.25 (A3), U9.9 (Zd)
MAR4: R4.1, U4.4 (Za), U6.26 (A4)
MAR5: R3.1, U4.7 (Zb), U6.1 (A5)
MAR6: R2.1, U4.12 (Zc), U6.2 (A6)
MAR7: R1.1, U4.9 (Zd), U6.3 (A7)
MASTER_CLK: R61.1, U1.7 (CK), U2.7 (CK), U3.7 (CK), U5.7 (CK), U7.2 (CP), U23.2 (CP), U25.7 (CK), U26.7 (CK), U27.7 (CK), U28.2 (CP), U29.7 (CK), U30.7 (CK), U31.7 (CK), U37.4
unnamed: C1.1, U22.5 (CV)
unnamed: C2.1, R60.2, U22.2 (TR), U22.6 (THR)
unnamed: C3.1, R65.2, U43.2 (TR), U43.6 (THR)
unnamed: C4.1, R67.2, U44.6 (THR), U44.7 (DIS)
unnamed: C5.1, U45.5 (CV)
unnamed: C6.1, U44.5 (CV)
unnamed: C7.1, U43.5 (CV)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: D6.2 (A), R6.2
unnamed: D7.2 (A), R7.2
unnamed: D8.2 (A), R8.2
unnamed: D9.1 (K), U10.7
unnamed: D9.2 (A), R9.2
unnamed: D10.1 (K), U10.9
unnamed: D10.2 (A), R10.2
unnamed: D11.1 (K), U10.10
unnamed: D11.2 (A), R11.2
unnamed: D12.1 (K), U10.11
unnamed: D12.2 (A), R13.2
unnamed: D13.1 (K), U10.12
unnamed: D13.2 (A), R14.2
unnamed: D14.1 (K), U10.13
unnamed: D14.2 (A), R24.2
unnamed: D15.1 (K), U10.14
unnamed: D15.2 (A), R25.2
unnamed: D16.1 (K), SW2.1 (A)
unnamed: D16.2 (A), R15.2, U4.1 (S), U9.1 (S)
unnamed: D17.1 (K), SW2.3 (C)
unnamed: D17.2 (A), R12.2
unnamed: D18.1 (K), U10.15
unnamed: D18.2 (A), R26.2
unnamed: D19.2 (A), R16.2
unnamed: D20.2 (A), R17.2
unnamed: D21.2 (A), R18.2
unnamed: D22.2 (A), R19.2
unnamed: D23.2 (A), R20.2
unnamed: D24.2 (A), R21.2
unnamed: D25.2 (A), R22.2
unnamed: D26.2 (A), R23.2
unnamed: D27.2 (A), R27.2
unnamed: D28.2 (A), R28.2
unnamed: D29.2 (A), R29.2
unnamed: D30.2 (A), R30.2
unnamed: D31.2 (A), R31.2
unnamed: D32.2 (A), R32.2
unnamed: D33.2 (A), R33.2
unnamed: D34.2 (A), R34.2
unnamed: D35.2 (A), R35.2
unnamed: D36.2 (A), R36.2
unnamed: D37.2 (A), R37.2
unnamed: D38.2 (A), R38.2
unnamed: D39.2 (A), R39.2
unnamed: D40.2 (A), R40.2
unnamed: D41.2 (A), R41.2
unnamed: D42.2 (A), R42.2
unnamed: D43.2 (A), R43.2
unnamed: D44.2 (A), R44.2
unnamed: D45.2 (A), R45.2
unnamed: D46.2 (A), R46.2
unnamed: D47.2 (A), R47.2
unnamed: D48.2 (A), R48.2
unnamed: D49.2 (A), R49.2
unnamed: D50.2 (A), R50.2
unnamed: D51.2 (A), R51.2
unnamed: D52.2 (A), R52.2
unnamed: D53.2 (A), R53.2
unnamed: D54.2 (A), R54.2
unnamed: D55.2 (A), R55.2
unnamed: D56.2 (A), R56.2
unnamed: D57.2 (A), R57.2
unnamed: D58.2 (A), R58.2
unnamed: D59.2 (A), R61.2
unnamed: D60.2 (A), R62.2
unnamed: D61.2 (A), R63.2
unnamed: D62.2 (A), R64.2
unnamed: R59.2, RV1.2, U22.7 (DIS)
unnamed: R60.1, RV1.3
unnamed: R65.1, RV2.3
unnamed: R66.2, RV2.2, U43.7 (DIS)
unnamed: R68.2, SW3.3 (C), U45.4 (R)
unnamed: R69.2, SW4.2, U44.2 (TR)
unnamed: R70.2, SW3.1 (A), U45.2 (TR)
unnamed: SW1.9, U9.3 (I1a)
unnamed: SW1.10, U9.6 (I1b)
unnamed: SW1.11, U9.13 (I1c)
unnamed: SW1.12, U9.10 (I1d)
unnamed: SW1.13, U4.3 (I1a)
unnamed: SW1.14, U4.6 (I1b)
unnamed: SW1.15, U4.13 (I1c)
unnamed: SW1.16, U4.10 (I1d)
unnamed: U1.3 (Q0), U4.2 (I0a)
unnamed: U1.4 (Q1), U4.5 (I0b)
unnamed: U1.5 (Q2), U4.14 (I0c)
unnamed: U1.6 (Q3), U4.11 (I0d)
unnamed: U2.3 (Q0), U9.2 (I0a)
unnamed: U2.4 (Q1), U9.5 (I0b)
unnamed: U2.5 (Q2), U9.14 (I0c)
unnamed: U2.6 (Q3), U9.11 (I0d)
unnamed: U7.14 (Q0), U8.21 (A0), U10.1, U11.21 (A0)
unnamed: U7.13 (Q1), U8.23 (A1), U10.2, U11.23 (A1)
unnamed: U7.12 (Q2), U8.24 (A2), U10.3, U11.24 (A2)
unnamed: U7.11 (Q3), U8.25 (A3), U11.25 (A3)
unnamed: U14.2 (A0), U28.14 (Q0)
unnamed: U14.3 (A1), U28.13 (Q1)
unnamed: U14.4 (A2), U28.12 (Q2)
unnamed: U14.5 (A3), U28.11 (Q3)
unnamed: U14.6 (A4), U23.14 (Q0)
unnamed: U14.7 (A5), U23.13 (Q1)
unnamed: U14.8 (A6), U23.12 (Q2)
unnamed: U14.9 (A7), U23.11 (Q3)
unnamed: U16.2 (A0), U20.4 (S1)
unnamed: U16.3 (A1), U20.1 (S2)
unnamed: U16.4 (A2), U20.13 (S3)
unnamed: U16.5 (A3), U20.10 (S4)
unnamed: U16.6 (A4), U21.4 (S1)
unnamed: U16.7 (A5), U21.1 (S2)
unnamed: U16.8 (A6), U21.13 (S3)
unnamed: U16.9 (A7), U21.10 (S4)
unnamed: U20.2 (B2), U33.6
unnamed: U20.6 (B1), U33.3
unnamed: U20.9 (C4), U21.7 (C0)
unnamed: U20.11 (B4), U33.11
unnamed: U20.15 (B3), U33.8
unnamed: U21.2 (B2), U34.6
unnamed: U21.6 (B1), U34.3
unnamed: U21.11 (B4), U34.11
unnamed: U21.15 (B3), U34.8
unnamed: U22.3 (Q), U35.2 (CP)
unnamed: U23.7 (CEP), U23.10 (CET), U28.15 (TC)
unnamed: U35.3 (D0), U35.4 (D1), U35.5 (D2), U35.6 (D3), U35.7 (CEP), U35.10 (CET)
unnamed: U35.13 (Q1), U36.5 (A9)
unnamed: U35.14 (Q0), U36.4 (A8)
unnamed: U37.1, U38.4
unnamed: U37.2, U39.4
unnamed: U38.1, U40.4
unnamed: U38.2, U41.4
unnamed: U41.1, U42.4
REGA_D0: R35.1, U15.2 (A0), U20.5 (A1), U25.3 (Q0)
REGA_D1: R36.1, U15.3 (A1), U20.3 (A2), U25.4 (Q1)
REGA_D2: R37.1, U15.4 (A2), U20.14 (A3), U25.5 (Q2)
REGA_D3: R38.1, U15.5 (A3), U20.12 (A4), U25.6 (Q3)
REGA_D4: R39.1, U15.6 (A4), U21.5 (A1), U29.3 (Q0)
REGA_D5: R40.1, U15.7 (A5), U21.3 (A2), U29.4 (Q1)
REGA_D6: R41.1, U15.8 (A6), U21.14 (A3), U29.5 (Q2)
REGA_D7: R42.1, U15.9 (A7), U21.12 (A4), U29.6 (Q3)
REGB_D0: R43.1, U17.2 (A0), U26.3 (Q0), U33.1
REGB_D1: R44.1, U17.3 (A1), U26.4 (Q1), U33.4
REGB_D2: R45.1, U17.4 (A2), U26.5 (Q2), U33.9
REGB_D3: R46.1, U17.5 (A3), U26.6 (Q3), U33.12
REGB_D4: R47.1, U17.6 (A4), U30.3 (Q0), U34.1
REGB_D5: R48.1, U17.7 (A5), U30.4 (Q1), U34.4
REGB_D6: R49.1, U17.8 (A6), U30.5 (Q2), U34.9
REGB_D7: R50.1, U17.9 (A7), U30.6 (Q3), U34.12
REGI_D0: R16.1, U5.3 (Q0), U8.26 (A4), U11.26 (A4), U12.2 (A0)
REGI_D1: R17.1, U5.4 (Q1), U8.1 (A5), U11.1 (A5), U12.3 (A1)
REGI_D2: R18.1, U5.5 (Q2), U8.2 (A6), U11.2 (A6), U12.4 (A2)
REGI_D3: R19.1, U5.6 (Q3), U8.3 (A7), U11.3 (A7), U12.5 (A3)
REGI_D4: R20.1, U3.3 (Q0), U8.4 (A8), U11.4 (A8), U12.6 (A4)
REGI_D5: R21.1, U3.4 (Q1), U8.5 (A9), U11.5 (A9), U12.7 (A5)
REGI_D6: R22.1, U3.5 (Q2), U8.6 (A10), U11.6 (A10), U12.8 (A6)
REGI_D7: R23.1, U3.6 (Q3), U8.7 (A11), U11.7 (A11), U12.9 (A7)
REGO_D0: R51.1, U18.2 (A0), U27.3 (Q0), U36.21 (A0)
REGO_D1: R52.1, U18.3 (A1), U27.4 (Q1), U36.23 (A1)
REGO_D2: R53.1, U18.4 (A2), U27.5 (Q2), U36.24 (A2)
REGO_D3: R54.1, U18.5 (A3), U27.6 (Q3), U36.25 (A3)
REGO_D4: R55.1, U18.6 (A4), U31.3 (Q0), U36.26 (A4)
REGO_D5: R56.1, U18.7 (A5), U31.4 (Q1), U36.1 (A5)
REGO_D6: R57.1, U18.8 (A6), U31.5 (Q2), U36.2 (A6)
REGO_D7: R58.1, U18.9 (A7), U31.6 (Q3), U36.3 (A7)
SO: U16.19 (CE)
SU: U11.18 (IO6), U20.7 (C0), U33.2, U33.5, U33.10, U33.13, U34.2, U34.5, U34.10, U34.13
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
Notes on the sheet:
Register A
ALU
CLOCK
Register B
Memory Address Register
Memory
Instruction Register
IO Register
Program Counter
Instruction Decoder

Board: 2 copper layers, 190 parts (0 on the bottom side), 210 nets, no tracks yet.

## Code that names these connections

File Software/STM32/HAL/io.h:

#ifndef _IO_h_
#define _IO_h_
	
#include "stm32f10x.h"

#ifdef __cplusplus 
extern "C"
{
#endif

typedef unsigned char u8;
typedef unsigned short u16;
typedef unsigned int u32;
typedef signed char s8;
typedef signed short s16;
typedef signed int s32;

typedef struct{
    GPIO_TypeDef* type;
    uint16_t pin;
    uint32_t rcc;
}GPIO;

void pinMode(const GPIO* gpio, int mode);
#define IO_MODE(n, v) pinMode((&(n)), (v))
#define IO_WRITE(n, v) (((v)==0) ? GPIO_ResetBits(n.type, n.pin) : GPIO_SetBits(n.type, n.pin))
#define IO_READ(n) GPIO_ReadInputDataBit(n.type, n.pin)
//#define IO_DELAY_MS(ms) delay_ms((ms))
//#define IO_DELAY_US(us) delay_us((us))

// emulate 8051
extern const GPIO PORT_A0;
extern const GPIO PORT_A1;
extern const GPIO PORT_A2;
extern const GPIO PORT_A3;
extern const GPIO PORT_A4;
extern const GPIO PORT_A5;
extern const GPIO PORT_A6;
extern const GPIO PORT_A7;

extern const GPIO PORT_A8 ;
extern const GPIO PORT_A9 ;
extern const GPIO PORT_A10;
extern const GPIO PORT_A11;
extern const GPIO PORT_A12;
extern const GPIO PORT_A13;
extern const GPIO PORT_A14;
extern const GPIO PORT_A15;

extern const GPIO PORT_B0 ;
extern const GPIO PORT_B1 ;
extern const GPIO PORT_B2 ;
extern const GPIO PORT_B3 ;
extern const GPIO PORT_B4 ;
extern const GPIO PORT_B5 ;
extern const GPIO PORT_B6 ;
extern const GPIO PORT_B7 ;

extern const GPIO PORT_B8 ;
extern const GPIO PORT_B9 ;
extern const GPIO PORT_B10;
extern const GPIO PORT_B11;
extern const GPIO PORT_B12;
extern const GPIO PORT_B13;
extern const GPIO PORT_B14;
extern const GPIO PORT_B15;

#define TBD1				PORT_C13
#define TBD2				PORT_C14
#define TBD3				PORT_C15
#define D0					PORT_A0		// P1.0
#define D1					PORT_A1		// P1.1
#define D2					PORT_A2		// P1.2
#define D3					PORT_A3		// P1.3
#define D4					PORT_A4		// P1.4
#define D5					PORT_A5		// P1.5
#define D6					PORT_A6		// P1.6
#define D7					PORT_A7		// P1.7
#define YM_CS				PORT_B0		// P3.2
#define WR					PORT_B1		// P3.3
#define A0					PORT_B10	// P3.5
#define A1					PORT_B11	// P3.6

#define SN_CLK_CS			PORT_B9  //  P0.4
#define SN_WR				PORT_B8  //  P0.2
#define RD					PORT_B7  /// P2.0
#define LCD_CS				PORT_B6  /// P2.1
#define SD_CS				PORT_B5  /// P0.6
#define YM_CLK_CS			PORT_B4  //  P0.3 // 
#define VGM_CS				PORT_B3  /// P0.7 //
#define BUTTON_MODE			PORT_A15 /// P2.2 //
#define BUTTON_NEXT			PORT_A12 /// P2.3
#define BUTTON_PREV			PORT_A11 /// P2.4
#define RXD					PORT_A10 //  P3.0
#define TXD					PORT_A9  //  P3.1
#define BUTTON_SEL			PORT_A8  /// P2.5
#define SPI_MOSI			PORT_B15 //  P0.1
#define SPI_MISO			PORT_B14 /// P0.5
#define SPI_CLK				PORT_B13 //  P0.0
#define RESET				PORT_B12 //  P3.7

#ifdef __cplusplus 
};
#endif
	
#endif

## Commit log

2018-12-04 FIRST VERSION
2018-12-07 asdasd
2018-12-08 ewsd
2018-12-08 Done!
2018-12-08 add FreeRoute.bat
2018-12-08 Done
2018-12-09 AddSound
2018-12-09 Solve buffer underflow
2018-12-10 add VGM.h
2018-12-10 Add VGM Support
2018-12-11 add KN053260 support
2018-12-11 Clearn Up Interfaces
2018-12-11 ADD SN76489
2018-12-11 Add GZ Support
2018-12-11 support vgz, add libz, add libopenal, add nes APU, add music
2018-12-11 fix bug in queued buffer count, always return 0. caused buffer overflow
2018-12-13 change TO C++ and MVC model
2018-12-13 change to cpp
2018-12-13 change SoundDevice To CPP
2018-12-13 add No Clamp
2018-12-13 add SDL2
2018-12-21 fix FFT
2018-12-24 fix header, try add looping
2019-01-11 change typedef
2022-10-18 Add Source Code
2022-10-20 Scale
2022-10-21 add image lib
2022-10-21 add Musics
2022-10-21 BigCamel
2022-10-21 add h
2022-10-21 fix key, and channel
2022-10-22 add Note View
2022-10-22 test
2022-10-22 Data
2022-10-22 Note Try
2022-10-22 Note 1st VErsion
2022-10-22 Viewer
2022-10-23 Move Everything in 1 Viewport
2022-10-23 music
2022-10-23 note
2022-10-24 add multi pcm
2022-10-24 multiupcm
2022-11-02 move directory
2022-11-02 change directory
2022-11-02 add lib
2022-11-02 move files
2022-11-02 add file
2022-11-02 add mmpeg
2022-11-04 encode ok
2022-11-05 encoding done
2022-11-05 refractor
2022-11-05 add font
2022-11-05 add chips
2022-11-05 add chip
2022-11-06 move background
2022-11-07 add freetype
2022-11-07 new layout
2022-11-07 dd ignore
2022-11-08 new player core
2022-11-08 change list directory method
2022-11-09 add OpenAL32.dll
2022-11-10 add channel buffers
2022-11-11 add multi channel
2022-11-12 add channel wave form
2022-11-12 add wave channel
2022-11-12 fix warning
2022-11-14 add channel
2022-11-18 add ignore list
2022-11-19 add nes wave form
2022-11-19 add ignore files
2022-11-19 add ignore
2022-11-25 add channel output
